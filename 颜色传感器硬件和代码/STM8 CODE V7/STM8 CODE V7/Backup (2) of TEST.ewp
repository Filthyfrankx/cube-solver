# IAR project Backup (2) of TEST.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S903K3 STM8S903K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: TEST.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; D:\Program Files\IAR FOR STM8\stm8\inc
  OBJCOPY.OOCOutputFile: TEST.srec
  ILINK.IlinkOutputFile: TEST.out
  group (top)
    ./: delay.c main.c Process.c tcs34725.c
